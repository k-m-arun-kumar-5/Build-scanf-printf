# Keil uVision project uart_07.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: uart_07 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s appl.c dev_oper.c gen_std_lib_part_1.c gen_std_lib_part_2.c io_lib.c isr.c lcd.c main.c uart.c appl.h conf_appl.h conf_dev_chs.h conf_io.h conf_misc_ids.h conf_port.h constants.h dev_oper.h gen_std_lib.h io_lib.h isr.h lcd.h main.h sys_status.h uart.h
